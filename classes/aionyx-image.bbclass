FEATURE_PACKAGES_aionyx-x11 = "packagegroup-core-x11"
FEATURE_PACKAGES_aionyx-x11[optional] = "1"
FEATURE_PACKAGES_aionyx-matchbox = "packagegroup-xilinx-matchbox"
FEATURE_PACKAGES_aionyx-matchbox[optional] = "1"
FEATURE_PACKAGES_aionyx-weston = "packagegroup-core-weston"
FEATURE_PACKAGES_aionyx-weston[optional] = "1"
FEATURE_PACKAGES_aionyx-self-hosted = "packagegroup-self-hosted vim"
FEATURE_PACKAGES_aionyx-self-hosted[optional] = "1"
FEATURE_PACKAGES_aionyx-benchmarks = "packagegroup-xilinx-benchmarks"
FEATURE_PACKAGES_aionyx-benchmarks[optional] = "1"
FEATURE_PACKAGES_aionyx-gstreamer = "packagegroup-xilinx-gstreamer"
FEATURE_PACKAGES_aionyx-gstreamer[optional] = "1"
FEATURE_PACKAGES_aionyx-audio = "packagegroup-xilinx-audio"
FEATURE_PACKAGES_aionyx-audio[optional] = "1"
FEATURE_PACKAGES_aionyx-openamp = "packagegroup-openamp"
FEATURE_PACKAGES_aionyx-openamp[optional] = "1"
FEATURE_PACKAGES_aionyx-multimedia = "packagegroup-xilinx-multimedia"
FEATURE_PACKAGES_aionyx-multimedia[optional] = "1"
FEATURE_PACKAGES_aionyx-networking-stack = "packagegroup-networking-stack"
FEATURE_PACKAGES_aionyx-networking-stack[optional] = "1"
FEATURE_PACKAGES_aionyx-v4lutils = "v4l-utils yavta"
FEATURE_PACKAGES_aionyx-v4lutils[optional] = "1"
FEATURE_PACKAGES_aionyx-lmsensors = "packagegroup-lmsensors"
FEATURE_PACKAGES_aionyx-lmsensors[optional] = "1"