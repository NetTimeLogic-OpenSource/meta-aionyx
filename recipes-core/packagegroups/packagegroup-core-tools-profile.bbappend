# Microblaze does not support the following tools
PERF:microblaze = ""
SYSTEMTAP:microblaze = ""
LTTNGTOOLS:microblaze = ""
BABELTRACE2:microblaze = ""
VALGRIND:microblaze = ""