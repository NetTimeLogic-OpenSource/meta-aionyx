DESCRIPTION = "OSL image definition for NetTimeLogic GmbH boards"
LICENSE = "MIT"

require aionyx-image-common.inc

IMAGE_NAME_SUFFIX ?= ""