PACKAGECONFIG:append = " tui"